# Keil uVision project STM32L1_AQI.uvprojx, settings and files
target STM32L1_AQI (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L152C8 STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32L1_AQI +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L152xB
  c include: ../Inc;  ../myLib\BMP280_STM32-master\BMP280;  ../myLib\GPS-master;  ../myLib\stm32-ssd1306-master\ssd1306;  C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_L1_V1.9.0/Drivers/STM32L1xx_HAL_Driver/Inc;  C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_L1_V1.9.0/Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;  C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_L1_V1.9.0/Drivers/CMSIS/Device/ST/STM32L1xx/Include;  C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_L1_V1.9.0/Drivers/CMSIS/Include;  ../myLib\AQI_thread
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Application/MDK-ARM
    ./: startup_stm32l152xb.s
  group Application/User
    ./: main_withwkbut.txt main_nowkbut.txt main_withbt1.txt
    ../Src/: main.c stm32l1xx_it.c stm32l1xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
  group BME280
    ../myLib/BMP280_STM32-master/BMP280/: bmp280.c
  group GPS
    ../myLib/GPS-master/: GPS.c
  group OLED
    ../myLib/stm32-ssd1306-master/ssd1306/: ssd1306.c ssd1306_fonts.c ssd1306_tests.c
  group Drivers/STM32L1xx_HAL_Driver
    C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_L1_V1.9.0/Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_i2c.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c
  group AQI_thread
    ../myLib/AQI_thread/: AQI_thread.h AQI_thread.c
software components: CMSIS:CORE 5.3.0, CMSIS:RTOS:Keil RTX 4.82.0, Device:Startup 2.0.0
